Commit message: Fix URDF and update joint_state_publisher

File: urdf/go_bdx.urdf (robot description, URDF)
Before this commit: robot bdx, 21 links, 20 joints
Links:
- added link base_link
Joints:
- added joint fixed_base: type fixed, parent base_link, child pelvis, origin xyz=0 0 0 rpy=0 0 0
